# Keil uVision project pro811.uvprojx, settings and files
target pro811 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: pro811
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ../Inc;                          ../Drivers/STM32F4xx_HAL_Driver/Inc;                          ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                          ../Drivers/CMSIS/Include;                          ../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_dac.c stm32f4xx_hal.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c main.c led.c pid_control.c uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Modbus
    ../Src/: mb.c mbcrc.c mbfuncholding.c mbrtu.c mbutils.c portevent.c portserial.c porttimer.c
software components: CMSIS:CORE 4.1.0
